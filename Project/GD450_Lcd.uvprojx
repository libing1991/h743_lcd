# Keil uVision project GD450_Lcd.uvprojx, settings and files
target main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\mcu;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\..\xmcu\inc;..\src\inc;..\..\xmcu\xhslib\inc;..\..\xmcu\lib\gdf450\GD32F4xx_standard_peripheral\Include;..\..\xmcu\os\RTX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c sys.c oscfg.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
  group mculib
    ../../xmcu/lib/gdf450/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_crc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dma.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_wwdgt.c gd32f4xx_can.c gd32f4xx_tli.c
  group driver
    ../../xmcu/src/: mcu_gd450.c
    ../mcu/: cpu.c RTX_Conf_CM.c
  group rtx
    ../../xmcu/os/RTX/: HAL_CM4.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c SVC_Table.s
